# IAR project vibrovacuum.ewp, settings and files
configuration vibrovacuum (ARM, debug)
  General.OGChipSelectEditMenu: STM32F746IG ST STM32F746IG
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Full.h
  General.CoreVariant: 41
  General.FPU2: 6
  ICCARM.CCDefines: USE_HAL_DRIVER; STM32F746xx; DISCONNECTED_BACKEND; NO_SERIALIZATION; USE_BPP=16
  ICCARM.CCIncludePath2: ../Core/Inc; ../Drivers/STM32F7xx_HAL_Driver/Inc; ../Drivers/STM32F7xx_HAL_Driver/Inc/Legacy; ../Drivers/CMSIS/Device/ST/STM32F7xx/Include; ../Drivers/CMSIS/Include; ..\app; ../TouchGFX/App; ../TouchGFX/target/generated; ../TouchGFX/target; ../Middlewares/Third_Party/FreeRTOS/Source/include; ../Middlewares/Third_Party/FreeRTOS/Source/CMSIS_RTOS_V2; ../Middlewares/Third_Party/FreeRTOS/Source/portable/IAR/ARM_CM7/r0p1; ../Middlewares/ST/touchgfx/framework/include; ../TouchGFX/generated/fonts/include; ../TouchGFX/generated/gui_generated/include; ../TouchGFX/generated/images/include; ../TouchGFX/generated/texts/include; ../TouchGFX/generated/videos/include; ../TouchGFX/gui/include
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 2
  AARM.AUserIncludes: ../Core/Inc
  OBJCOPY.OOCOutputFile: vibrovacuum.hex
  ILINK.IlinkOutputFile: vibrovacuum.out
  ILINK.IlinkIcfFile: C:\Users\Sergey\YandexDisk\Work\Projects\Vibrovacuum\Software\vibrovacuum_tgfx_4.22.1_iar\EWARM\stm32f746xx_flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group (top)
    ./: vibrovacuum.ipcf
  group app/backend
    ../app/backend/: api.cpp api.hpp
  group app/backend/pressure_sensor
    ../app/devices/pressure_sensor/: pressure_sensor_controller.cpp pressure_sensor_controller.hpp
  group app/backend/pump
    ../app/devices/pump/: pump_controller.cpp pump_controller.hpp pump_states.hpp
  group app/components/flash
    ../app/components/flash/: n25q128a.h n25q128a_qspi.c n25q128a_qspi.h
  group app/components/lcd_touch
    ../app/components/lcd_touch/: lcd_touch.cpp lcd_touch.hpp
  group app/components/sdram
    ../app/components/sdram/: is42S16400j-7tli.c is42S16400j-7tli.h
  group app/components/touch
    ../app/components/touch/: CT_I2C.c CT_I2C.h gt811.c gt811.h gt811_waveshare.c gt811_waveshare.h gt911.c gt911.h touch_screen_factory.hpp touch_screen_interface.hpp TS_I2C.c TS_I2C.h
  group app/periphery_drivers/adc
    ../app/periphery_drivers/adc/: adc_controller.cpp adc_controller.hpp
  group app/periphery_drivers/interrupt_manager
    ../app/periphery_drivers/interrupt_manager/: interrupt_manager.cpp interrupt_manager.hpp
  group app/periphery_drivers/pwm
    ../app/periphery_drivers/pwm/: pwm_controller.hpp
  group app/tests
    ../app/tests/: config_tests.h dma2d_tests.c dma2d_tests.h flash_tests.c flash_tests.h ltdc_tests.c ltdc_tests.h RGB565_240x130_1.h RGB565_240x130_2.h sdram_tests.c sdram_tests.h
  group app/utility
    ../app/utility/: software_pwm.cpp software_pwm.hpp timer_facility.cpp timer_facility.hpp
  group Application/EWARM
    ./: startup_stm32f746xx.s
  group Application/User/Core
    ../Core/Src/: main.c gpio.c freertos.c adc.c crc.c dma2d.c fmc.c i2c.c ltdc.c quadspi.c tim.c stm32f7xx_it.c stm32f7xx_hal_msp.c stm32f7xx_hal_timebase_tim.c
  group Application/User/TouchGFX/App
    ../TouchGFX/App/: app_touchgfx.c
  group Application/User/TouchGFX/target
    ../TouchGFX/target/: TouchGFXHAL.cpp STM32TouchController.cpp TouchGFXGPIO.cpp
  group Application/User/TouchGFX/target/generated
    ../TouchGFX/target/generated/: TouchGFXConfiguration.cpp TouchGFXGeneratedHAL.cpp STM32DMA.cpp OSWrappers.cpp
  group Drivers/CMSIS
    ../Core/Src/: system_stm32f7xx.c
  group Drivers/STM32F7xx_HAL_Driver
    ../Drivers/STM32F7xx_HAL_Driver/Src/: stm32f7xx_hal_adc.c stm32f7xx_hal_adc_ex.c stm32f7xx_hal_rcc.c stm32f7xx_hal_rcc_ex.c stm32f7xx_hal_flash.c stm32f7xx_hal_flash_ex.c stm32f7xx_hal_gpio.c stm32f7xx_hal_dma.c stm32f7xx_hal_dma_ex.c stm32f7xx_hal_pwr.c stm32f7xx_hal_pwr_ex.c stm32f7xx_hal_cortex.c stm32f7xx_hal.c stm32f7xx_hal_i2c.c stm32f7xx_hal_i2c_ex.c stm32f7xx_hal_exti.c stm32f7xx_hal_crc.c stm32f7xx_hal_crc_ex.c stm32f7xx_hal_dma2d.c stm32f7xx_ll_fmc.c stm32f7xx_hal_sdram.c stm32f7xx_hal_ltdc.c stm32f7xx_hal_ltdc_ex.c stm32f7xx_hal_dsi.c stm32f7xx_hal_qspi.c stm32f7xx_hal_tim.c stm32f7xx_hal_tim_ex.c
  group Middlewares/FreeRTOS
    ../Middlewares/Third_Party/FreeRTOS/Source/: croutine.c event_groups.c list.c queue.c stream_buffer.c tasks.c timers.c
    ../Middlewares/Third_Party/FreeRTOS/Source/CMSIS_RTOS_V2/: cmsis_os2.c
    ../Middlewares/Third_Party/FreeRTOS/Source/portable/MemMang/: heap_4.c
    ../Middlewares/Third_Party/FreeRTOS/Source/portable/IAR/ARM_CM7/r0p1/: port.c portasm.s
  group TouchGFX/generated/fonts
    ../TouchGFX/generated/fonts/src/: ApplicationFontProvider.cpp CachedFont.cpp Font_RobotoCondensed_Regular_10_4bpp_0.cpp Font_RobotoCondensed_Regular_20_4bpp_0.cpp Font_RobotoCondensed_Regular_30_4bpp_0.cpp Font_RobotoCondensed_Regular_40_4bpp_0.cpp Font_RobotoCondensed_Regular_60_4bpp_0.cpp FontCache.cpp GeneratedFont.cpp Kerning_RobotoCondensed_Regular_10_4bpp.cpp Kerning_RobotoCondensed_Regular_20_4bpp.cpp Kerning_RobotoCondensed_Regular_30_4bpp.cpp Kerning_RobotoCondensed_Regular_40_4bpp.cpp Kerning_RobotoCondensed_Regular_60_4bpp.cpp Table_RobotoCondensed_Regular_10_4bpp.cpp Table_RobotoCondensed_Regular_20_4bpp.cpp Table_RobotoCondensed_Regular_30_4bpp.cpp Table_RobotoCondensed_Regular_40_4bpp.cpp Table_RobotoCondensed_Regular_60_4bpp.cpp UnmappedDataFont.cpp
  group TouchGFX/generated/gui_generated
    ../TouchGFX/generated/gui_generated/src/electrostim1_screen/: Electrostim1ViewBase.cpp
    ../TouchGFX/generated/gui_generated/src/electrostim2_screen/: Electrostim2ViewBase.cpp
    ../TouchGFX/generated/gui_generated/src/common/: FrontendApplicationBase.cpp
    ../TouchGFX/generated/gui_generated/src/main_screen/: MainViewBase.cpp
    ../TouchGFX/generated/gui_generated/src/containers/: NonclickableZone256ContainerBase.cpp NonclickableZone900ContainerBase.cpp NonclickableZoneContainerBase.cpp
    ../TouchGFX/generated/gui_generated/src/vacuum_screen/: VacuumViewBase.cpp
    ../TouchGFX/generated/gui_generated/src/vibration_screen/: VibrationViewBase.cpp
  group TouchGFX/generated/images
    ../TouchGFX/generated/images/src/: BitmapDatabase.cpp image_button_invisible_256.cpp image_dottedLineH.cpp image_dottedLineV.cpp image_electricity-therapy.cpp image_icon_stop.cpp image_jackhammer.cpp image_Rectangle-900-blank.cpp image_Rectangle-900-green.cpp image_Rectangle-blank-128.cpp image_Rectangle-blank.cpp image_Rectangle-green-128.cpp image_Rectangle-purple.cpp image_Rectangle-ros.cpp image_Rectangle_gr.cpp image_Rectangle_green.cpp image_Rectanlge-green-128.cpp image_Rectanlge-green.cpp image_right-arrow-angle.cpp image_stopwatch_64.cpp image_vacuum-cleaner-bk.cpp SVGDatabase.cpp
    ../TouchGFX/generated/images/src/__designer/: image_Dark_Slider_Horizontal_Medium_Indicators_Slider2_Round_Edge_nob.cpp image_Dark_Slider_Horizontal_Medium_Slider2_Round_Edge_fill.cpp image_Dark_Slider_Vertical_Small_Indicators_Slider3_Vertical_Round_Edge_nob.cpp image_Dark_Slider_Vertical_Small_Slider3_Vertical_Round_Edge_fill.cpp image_Dark_Textures_tweed.cpp image_Dark_Textures_vertical_cloth.cpp
  group TouchGFX/generated/texts
    ../TouchGFX/generated/texts/src/: LanguageGb.cpp Texts.cpp TypedTextDatabase.cpp
  group TouchGFX/gui/common
    ../TouchGFX/gui/src/common/: FrontendApplication.cpp GuiUtilities.cpp
  group TouchGFX/gui/containers
    ../TouchGFX/gui/src/containers/: NonclickableZone256Container.cpp NonclickableZone900Container.cpp NonclickableZoneContainer.cpp
  group TouchGFX/gui/electrostim1_screen
    ../TouchGFX/gui/src/electrostim1_screen/: Electrostim1Presenter.cpp Electrostim1View.cpp
  group TouchGFX/gui/electrostim2_screen
    ../TouchGFX/gui/src/electrostim2_screen/: Electrostim2Presenter.cpp Electrostim2View.cpp
  group TouchGFX/gui/main_screen
    ../TouchGFX/gui/src/main_screen/: MainPresenter.cpp MainView.cpp
  group TouchGFX/gui/model
    ../TouchGFX/gui/src/model/: Model.cpp
  group TouchGFX/gui/vacuum_screen
    ../TouchGFX/gui/src/vacuum_screen/: VacuumPresenter.cpp VacuumView.cpp
  group TouchGFX/gui/vibration_screen
    ../TouchGFX/gui/src/vibration_screen/: VibrationPresenter.cpp VibrationView.cpp
  group TouchGFX/Lib
    ../Middlewares/ST/touchgfx/lib/core/cortex_m7/IAR9.x/: touchgfx_core.a
